require u-boot-alientek-common.inc
require u-boot-source-2026.07.inc
require recipes-bsp/u-boot/u-boot-tools.inc
require u-boot-tools-alientek.inc
