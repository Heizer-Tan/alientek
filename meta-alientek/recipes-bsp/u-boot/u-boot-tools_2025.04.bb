require u-boot-common_2025.04.inc
require recipes-bsp/u-boot/u-boot-tools.inc
