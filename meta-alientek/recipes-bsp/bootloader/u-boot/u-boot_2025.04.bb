require u-boot-alientek-common.inc
require u-boot-source-2025.04.inc
require u-boot-target-alientek.inc
require recipes-bsp/u-boot/u-boot.inc
